# Keil uVision project MCU-8bit-Full-Color-Water-Lamp-Template-V1.0.uvproj, settings and files
target STC15W204S (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: MCU-8bit-Full-Color-Water-Lamp-Template +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: STARTUP.A51 Main.c
  group WS2812
    ./: ws2812.c
  group Delay
    ./: Delay.c
